Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 956314df-88b6-42cf-890a-8e26c454a2ac, NumberOfSaves: 65], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_FallProtection_Vertbasew_285mm.ifc
Time: 2025-10-27T13:37:03
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcBuildingElementProxy: Attrezzature speciali : ROTHOB_Rothoblaas_FallProtection_Vertbasew : VERTBASEW_141x410x139mm
In: 0_Rothoblaas
Type - ElementType: FALL_ARRESTER_DEVICES; PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_StainlessSteelAISI304
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_Vertbasew; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-lines/vertigrip-on-wall; Revision: 000; UniClass2015Code: Pr_40_70_75_29; UniClass2015Title: Fall arrester devices; UniClass2015Version: Products v1.39; Version: 001
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteelAISI304
Type - Quote - Height_H: 138.666 mm; Length_L: 410.016 mm; Width_B: 141.363 mm
Type - Dati identità - Descrizione: Lower support for Vertigrip system on wall; Nome del tipo: VERTBASEW_141x410x139mm; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Attrezzature speciali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_29 - Fall arrester devices; CodePerformance: Safety system; Color: Silver; Constituents: Tubular, plate, bolts, nuts; DurationUnit: Years; ExpectedLife: n/a; Features: Vertical lifeline; Finish: Stainless steel; Grade: n/a; GTIN: 8033564766169; Material: AISI 304 stainless steel grade 1.4301; MinWeight: 1.94 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: VERTBASEW; ModelReference: n/a; Name: Lower support; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_Vertbasew; NominalHeight: 138.666 mm; NominalLength: 410.016 mm; NominalWidth: 141.363 mm; ReferenceStandard: EN 353-1:2014+A1:2017 | RfU11.119 | AS/NZS 1891.3:2020; ReplacementCost: n/a; Shape: Three-dimensional; Size: 141x410x139 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Lower support; Category: Pr_40_70_75_29 - Fall arrester devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: VERTBASEW_141x410x139mm; sets with these values: 2
Vincoli - Host: Piano di riferimento : REF; Quota altimetrica da livello: 0 mm; Support_Position: 1
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.0957282 m2; Lifeline_OffsetFromSubstructure: 285.016 mm; Support_Position_Length: 10.0157 mm; Volume: 0.000229441 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_Vertbasew; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_Vertbasew: VERTBASEW_141x410x139mm; ID tipo: 804336; Tipo: VERTBASEW_141x410x139mm
