Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 956314df-88b6-42cf-890a-8e26c454a2ac, NumberOfSaves: 65], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_FallProtection_Vertslide_0-0.ifc
Time: 2025-10-27T14:33:23
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcBuildingElementProxy: Attrezzature speciali : ROTHOB_Rothoblaas_FallProtection_Vertslide : VERTSLIDE_66x90x303mm
In: 0_Rothoblaas
Type - ElementType: FALL_ARRESTER_DEVICES; PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_StainlessSteelAISI304, ROTHOB_Rothoblaas_Polyamide_Orange, ROTHOB_Rothoblaas_PolyamidePA6, ROTHOB_Rothoblaas_Brass, ROTHOB_Rothoblaas_Aluminium7075, ROTHOB_Rothoblaas_Aluminium7075_Black
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_Vertslide; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fall-protection-system/anchor-lines/vertigrip; Revision: 000; UniClass2015Code: Pr_40_70_75_29; UniClass2015Title: Fall arrester devices; UniClass2015Version: Products v1.39; Version: 001
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteelAISI304; ObjectMaterial_Absorber: ROTHOB_Rothoblaas_Polyamide_Orange; ObjectMaterial_Connector: ROTHOB_Rothoblaas_Aluminium7075; ObjectMaterial_Flange: ROTHOB_Rothoblaas_Aluminium7075_Black; ObjectMaterial_PA6: ROTHOB_Rothoblaas_PolyamidePA6; ObjectMaterial_Spacer: ROTHOB_Rothoblaas_Brass
Type - Quote - Height_H: 302.877 mm; Length_L: 89.813 mm; Width_B: 66.411 mm
Type - Dati identità - Descrizione: Removable sliding fall protection device with energy absorber; Nome del tipo: VERTSLIDE_66x90x303mm; Numero OmniClass: 23.27.71.21; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Attrezzature speciali; AccessibilityPerformance: n/a; AssetType: Sliding; Category: Pr_40_70_75_29 - Fall arrester devices; CodePerformance: Safety system; Color: Silver/Black; Constituents: Flanges, spacers, levers, pins, absorber, connector; DurationUnit: Years; ExpectedLife: n/a; Features: Vertical lifeline; Finish: n/a; Grade: n/a; GTIN: 8052877754786; Manufacturer_x: info@rothoblaas.com; Material: AISI 304 stainless steel grade 1.4301 / EN AW 7075 T6 Aluminimu alloy / Polyamide; MinWeight: 0.47 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: VERTSLIDE; ModelReference: n/a; Name: Guided Type Fall Arrester; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_Vertslide; NominalHeight: 302.877 mm; NominalLength: 89.813 mm; NominalWidth: 66.411 mm; ReferenceStandard: EN 353-1:2014+A1:2017 | RfU11.119 | AS/NZS 1891.3:2020; ReplacementCost: n/a; Shape: Three-dimensional; Size: 66x90x303 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver/Black
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Guided Type Fall Arrester; Category: Pr_40_70_75_29 - Fall arrester devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Material: ROTHOB_Rothoblaas_Aluminium7075, ROTHOB_Rothoblaas_Polyamide_Orange, ROTHOB_Rothoblaas_PolyamidePA6, ROTHOB_Rothoblaas_StainlessSteelAISI304, ROTHOB_Rothoblaas_Aluminium7075_Black, ROTHOB_Rothoblaas_Brass
Pset_BuildingElementProxyCommon - Reference: VERTSLIDE_66x90x303mm; sets with these values: 2
Vincoli - Host: Piano di riferimento : REF; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Absorber_Angle: 0 deg; Absorber_Angle_Ctrl: 0 deg; Area: 0.0347744 m2; Connector_Angle: 0 deg; Volume: 0.000152393 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_Vertslide; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_Vertslide: VERTSLIDE_66x90x303mm; ID tipo: 930961; Tipo: VERTSLIDE_66x90x303mm
