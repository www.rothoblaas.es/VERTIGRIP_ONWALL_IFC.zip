Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 956314df-88b6-42cf-890a-8e26c454a2ac, NumberOfSaves: 65], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_FallProtection_Vertspear_Tensioner.ifc
Time: 2025-10-27T14:38:18
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcBuildingElementProxy: Attrezzature speciali : ROTHOB_Rothoblaas_FallProtection_Vertspear_Tensioner : VERTSPEAR_60x84x323mm
In: 0_Rothoblaas
Type - ElementType: FALL_ARRESTER_DEVICES; PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_StainlessSteelAISI304, ROTHOB_Rothoblaas_Aluminium6082
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_Vertspear_Tensioner; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fall-protection-system/anchor-lines/vertigrip-on-wall; Revision: 000; UniClass2015Code: Pr_40_70_75_29; UniClass2015Title: Fall arrester devices; UniClass2015Version: Products v1.39; Version: 001
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteelAISI304; ObjectMaterial_Clamp: ROTHOB_Rothoblaas_Aluminium6082
Type - Quote - Height_H: 323 mm; Length_L: 83.5 mm; Width_B: 60.4 mm
Type - Dati identità - Descrizione: Set for clamps and tensioner; Nome del tipo: VERTSPEAR_60x84x323mm; Numero OmniClass: 23.27.71.21; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Attrezzature speciali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_29 - Fall arrester devices; CodePerformance: Safety system; Color: Silver; Constituents: Spring, Fastening, Clamps; DurationUnit: Years; ExpectedLife: n/a; Features: Vertical lifeline; Finish: Stainless steel; Grade: n/a; GTIN: 8052877754885; Manufacturer_x: info@rothoblaas.com; Material: AISI 304 stainless steel grade 1.4301 / EN AW 6082 aluminium; MinWeight: 2.60 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: VERTSPEAR; ModelReference: n/a; Name: Tensioner; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_Vertspear_Tensioner; NominalHeight: 323 mm; NominalLength: 83.5 mm; NominalWidth: 60.4 mm; ReferenceStandard: EN 353-1:2014+A1:2017 | RfU11.119 | AS/NZS 1891.3:2020; ReplacementCost: n/a; Shape: Three-dimensional; Size: 60x84x323 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Tensioner; Category: Pr_40_70_75_29 - Fall arrester devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: VERTSPEAR_60x84x323mm; sets with these values: 2
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.0488067 m2; Volume: 0.000184858 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_Vertspear_Tensioner; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_Vertspear_Tensioner: VERTSPEAR_60x84x323mm; ID tipo: 957629; Tipo: VERTSPEAR_60x84x323mm
